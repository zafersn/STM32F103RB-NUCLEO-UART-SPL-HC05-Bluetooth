# IAR project 05-USART-TEST-HC05.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: ; 04-Application_Layer\4.3-HVAC\4.3.1-inc; 04-Application_Layer\4.3-HVAC\4.3.2-src; 04-Application_Layer\4.1-inc; 04-Application_Layer\4.2-src; 03-Middle_Layer\3.1-inc; 03-Middle_Layer\3.1-src; 02-Drivers\2.1-inc; 02-Drivers\2.2-src; 02-Drivers\2.3-Project_Name\2.3.1-inc; 02-Drivers\2.3-Project_Name\2.3.2-src; D:\01-ARGE\01-Ges_Lib\01-Software\01-ST32_Lib\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries; D:\01-ARGE\01-Ges_Lib\01-Software\01-ST32_Lib\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc\; D:\01-ARGE\01-Ges_Lib\01-Software\01-ST32_Lib\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\CoreSupport\; D:\01-ARGE\01-Ges_Lib\01-Software\01-ST32_Lib\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\; D:\01-ARGE\01-Ges_Lib\01-Software\02-STM32F103_Drivers; D:\01-ARGE\01-Ges_Lib\01-Software\02-STM32F103_Drivers\02-Drivers\2.1-inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 05-USART-TEST-HC05.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group 01-STD_Libraries
    ../../../01-Ges_Lib/01-Software/01-ST32_Lib/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../01-Ges_Lib/01-Software/01-ST32_Lib/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
    ../../../01-Ges_Lib/01-Software/01-ST32_Lib/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c system_stm32f10x.h
  group 02-Drivers/2.2-src
    ../../../01-Ges_Lib/01-Software/01-ST32_Lib/STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group 03-Middle_Layer
    ./: main.c
