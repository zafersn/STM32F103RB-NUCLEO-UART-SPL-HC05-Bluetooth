<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\05-USART-TEST-HC05.ewp</path>
    </project>
    <batchBuild />
</workspace>
